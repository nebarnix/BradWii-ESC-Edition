# Keil uVision project bradwii-V202.uvproj, settings and files
target bradwii-V202 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MINI54ZAN Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: bradwii-V202
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: V202_BUILD
  c misc: --gnu --C99
  c include: lib-Mini51\hal;src;lib-Mini51\CMSIS\Include;lib-Mini51\Device\Nuvoton\Mini51Series\Include;lib-Mini51\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group App
    ./src/: accelerometer.c autotune.c baro.c bradwii.c checkboxes.c compass.c eeprom.c gps.c gyro.c imu.c navigation.c output.c pilotcontrol.c serial.c vectors.c rx_v202.c nrf24l01.c leds.c
  group HAL
    ./lib-Mini51/hal/: drv_gpio.c drv_hal.c drv_pwm.c drv_serial.c lib_digitalio.c lib_fp.c lib_i2c.c lib_serial.c lib_timers.c lib_spi.c lib_adc.c
  group StdDriver
    ./lib-Mini51/StdDriver/src/: adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c
  group CMSIS
    ./lib-Mini51/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ./lib-Mini51/: startup_Mini51Series.s
