# Keil uVision project bradwii.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bradwii +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99 --gnu
  c include: lib\hal;src;lib\CMSIS\CM3\CoreSupport;lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;lib\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./src/: accelerometer.c autotune.c baro.c bradwii.c checkboxes.c compass.c eeprom.c gps.c gyro.c imu.c navigation.c output.c pilotcontrol.c rx.c serial.c vectors.c leds.c
  group HAL
    ./lib/hal/: lib_digitalio.c lib_fp.c lib_i2c.c lib_serial.c lib_timers.c drv_hal.c drv_gpio.c drv_serial.c drv_pwm.c
  group StdPeriphLib
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./lib/: startup_stm32f10x_md.s
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c
